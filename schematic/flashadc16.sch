v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 850 -1080 850 -970 {lab=VDD}
N 850 -790 850 -700 {lab=GND}
N 670 -840 790 -840 {lab=vbias}
N 850 -1490 850 -1380 {lab=VDD}
N 850 -1220 850 -1110 {lab=GND}
N 670 -1250 790 -1250 {lab=vbias}
N 850 -1910 850 -1800 {lab=VDD}
N 850 -1640 850 -1530 {lab=GND}
N 670 -1670 790 -1670 {lab=vbias}
N 980 -1720 1110 -1720 {lab=#net1}
N 850 -2320 850 -2210 {lab=VDD}
N 850 -2050 850 -1940 {lab=GND}
N 670 -2080 790 -2080 {lab=vbias}
N 980 -2130 1170 -2130 {lab=#net2}
N 850 -2730 850 -2620 {lab=VDD}
N 850 -2460 850 -2350 {lab=GND}
N 670 -2490 790 -2490 {lab=vbias}
N 980 -2540 1110 -2540 {lab=#net3}
N 850 -3140 850 -3030 {lab=VDD}
N 850 -2870 850 -2760 {lab=GND}
N 670 -2900 790 -2900 {lab=vbias}
N 980 -2950 1110 -2950 {lab=#net4}
N 850 -3560 850 -3450 {lab=VDD}
N 850 -3290 850 -3180 {lab=GND}
N 670 -3320 790 -3320 {lab=vbias}
N 980 -3370 1110 -3370 {lab=#net5}
N 850 -3970 850 -3860 {lab=VDD}
N 850 -3700 850 -3590 {lab=GND}
N 670 -3730 790 -3730 {lab=vbias}
N 980 -3780 1110 -3780 {lab=#net6}
N 850 -4380 850 -4270 {lab=VDD}
N 850 -4110 850 -4000 {lab=GND}
N 670 -4140 790 -4140 {lab=vbias}
N 980 -4190 1110 -4190 {lab=#net7}
N 850 -4790 850 -4680 {lab=VDD}
N 850 -4520 850 -4410 {lab=GND}
N 670 -4550 790 -4550 {lab=vbias}
N 980 -4600 1110 -4600 {lab=#net8}
N 850 -5210 850 -5100 {lab=VDD}
N 850 -4940 850 -4830 {lab=GND}
N 670 -4970 790 -4970 {lab=vbias}
N 980 -5020 1110 -5020 {lab=#net9}
N 850 -5620 850 -5510 {lab=VDD}
N 850 -5350 850 -5240 {lab=GND}
N 670 -5380 790 -5380 {lab=vbias}
N 980 -5430 1110 -5430 {lab=#net10}
N 850 -6030 850 -5920 {lab=VDD}
N 850 -5760 850 -5650 {lab=GND}
N 670 -5790 790 -5790 {lab=vbias}
N 980 -5840 1110 -5840 {lab=#net11}
N 850 -6440 850 -6330 {lab=VDD}
N 850 -6170 850 -6060 {lab=GND}
N 670 -6200 790 -6200 {lab=vbias}
N 980 -6250 1110 -6250 {lab=#net12}
N 850 -6590 850 -6480 {lab=GND}
N 670 -6620 790 -6620 {lab=vbias}
N 980 -6670 1110 -6670 {lab=#net13}
N 640 -910 790 -910 {lab=vin}
N 640 -1320 640 -910 {lab=vin}
N 640 -1320 790 -1320 {lab=vin}
N 640 -1740 640 -1320 {lab=vin}
N 640 -1740 790 -1740 {lab=vin}
N 640 -2150 640 -1740 {lab=vin}
N 640 -2150 790 -2150 {lab=vin}
N 640 -2560 640 -2150 {lab=vin}
N 640 -2560 790 -2560 {lab=vin}
N 640 -2970 640 -2560 {lab=vin}
N 640 -2970 790 -2970 {lab=vin}
N 640 -3390 640 -2970 {lab=vin}
N 640 -3390 790 -3390 {lab=vin}
N 640 -3800 640 -3390 {lab=vin}
N 640 -3800 790 -3800 {lab=vin}
N 640 -4210 640 -3800 {lab=vin}
N 640 -4210 790 -4210 {lab=vin}
N 640 -4620 640 -4210 {lab=vin}
N 640 -4620 790 -4620 {lab=vin}
N 640 -5040 640 -4620 {lab=vin}
N 640 -5040 790 -5040 {lab=vin}
N 640 -5450 640 -5040 {lab=vin}
N 640 -5450 790 -5450 {lab=vin}
N 640 -5860 640 -5450 {lab=vin}
N 640 -5860 790 -5860 {lab=vin}
N 640 -6270 640 -5860 {lab=vin}
N 640 -6270 790 -6270 {lab=vin}
N 640 -6690 640 -6270 {lab=vin}
N 640 -6690 790 -6690 {lab=vin}
N 500 -6650 790 -6650 {lab=ref15}
N 500 -6810 500 -6650 {lab=ref15}
N 500 -6650 500 -6460 {lab=ref15}
N 500 -6230 790 -6230 {lab=ref14}
N 500 -6230 500 -6050 {lab=ref14}
N 500 -5990 500 -5820 {lab=ref13}
N 500 -5820 790 -5820 {lab=ref13}
N 500 -6400 500 -6230 {lab=ref14}
N 500 -5820 500 -5640 {lab=ref13}
N 500 -5580 500 -5410 {lab=ref12}
N 500 -5410 790 -5410 {lab=ref12}
N 500 -5410 500 -5230 {lab=ref12}
N 500 -5170 500 -5000 {lab=ref11}
N 500 -5000 790 -5000 {lab=ref11}
N 500 -4580 790 -4580 {lab=ref10}
N 500 -5000 500 -4810 {lab=ref11}
N 500 -4170 790 -4170 {lab=ref9}
N 500 -4580 500 -4400 {lab=ref10}
N 500 -4750 500 -4580 {lab=ref10}
N 500 -3760 790 -3760 {lab=ref8}
N 500 -4170 500 -3990 {lab=ref9}
N 500 -4340 500 -4170 {lab=ref9}
N 500 -3520 500 -3350 {lab=ref7}
N 500 -3350 790 -3350 {lab=ref7}
N 500 -3760 500 -3580 {lab=ref8}
N 500 -3930 500 -3760 {lab=ref8}
N 500 -2930 790 -2930 {lab=ref6}
N 500 -3350 500 -3160 {lab=ref7}
N 500 -2520 790 -2520 {lab=ref5}
N 500 -2930 500 -2750 {lab=ref6}
N 500 -3100 500 -2930 {lab=ref6}
N 500 -2110 790 -2110 {lab=ref4}
N 500 -2520 500 -2340 {lab=ref5}
N 500 -2690 500 -2520 {lab=ref5}
N 500 -1870 500 -1700 {lab=ref3}
N 500 -1700 790 -1700 {lab=ref3}
N 500 -2110 500 -1930 {lab=ref4}
N 500 -2280 500 -2110 {lab=ref4}
N 500 -1280 790 -1280 {lab=ref2}
N 500 -1700 500 -1510 {lab=ref3}
N 500 -1040 500 -870 {lab=GND}
N 500 -870 790 -870 {lab=GND}
N 500 -1280 500 -1100 {lab=ref2}
N 500 -1450 500 -1280 {lab=ref2}
N 500 -870 500 -790 {lab=GND}
N 500 -790 850 -790 {lab=GND}
N 850 -810 850 -790 {lab=GND}
N 50 -6920 50 -6860 {lab=GND}
N 50 -7060 50 -6980 {lab=VDD}
N 130 -6920 130 -6860 {lab=GND}
N 130 -7060 130 -6980 {lab=vbias}
N 50 -6800 50 -6600 {lab=GND}
N 130 -6660 130 -6600 {lab=GND}
N 130 -6800 130 -6720 {lab=vin}
N 850 -6910 850 -6750 {lab=VDD}
N 500 -6910 850 -6910 {lab=VDD}
N 500 -6910 500 -6870 {lab=VDD}
N 1230 -910 1270 -910 {lab=#net14}
N 980 -890 990 -890 {lab=#net15}
N 1080 -890 1110 -890 {lab=#net16}
N 1070 -930 1110 -930 {lab=#net17}
N 1070 -1300 1070 -930 {lab=#net17}
N 980 -1300 1070 -1300 {lab=#net17}
N 1550 -950 1590 -950 {lab=#net18}
N 1390 -930 1430 -930 {lab=#net19}
N 1110 -1720 1110 -950 {lab=#net1}
N 1110 -950 1270 -950 {lab=#net1}
N 1170 -2130 1170 -970 {lab=#net2}
N 1170 -970 1430 -970 {lab=#net2}
C {Opamp.sym} 830 -890 0 0 {name=x1}
C {lab_wire.sym} 850 -1040 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -740 0 0 {name=p2 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -840 0 0 {name=p3 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -1300 0 0 {name=x2}
C {lab_wire.sym} 850 -1450 0 0 {name=p4 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -1150 0 0 {name=p5 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -1250 0 0 {name=p6 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -1720 0 0 {name=x3}
C {lab_wire.sym} 850 -1870 0 0 {name=p7 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -1570 0 0 {name=p8 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -1670 0 0 {name=p9 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -2130 0 0 {name=x4}
C {lab_wire.sym} 850 -2280 0 0 {name=p10 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -1980 0 0 {name=p11 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -2080 0 0 {name=p12 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -2540 0 0 {name=x5}
C {lab_wire.sym} 850 -2690 0 0 {name=p13 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -2390 0 0 {name=p14 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -2490 0 0 {name=p15 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -2950 0 0 {name=x6}
C {lab_wire.sym} 850 -3100 0 0 {name=p16 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -2800 0 0 {name=p17 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -2900 0 0 {name=p18 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -3370 0 0 {name=x7}
C {lab_wire.sym} 850 -3520 0 0 {name=p19 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -3220 0 0 {name=p20 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -3320 0 0 {name=p21 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -3780 0 0 {name=x8}
C {lab_wire.sym} 850 -3930 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -3630 0 0 {name=p23 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -3730 0 0 {name=p24 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -4190 0 0 {name=x9}
C {lab_wire.sym} 850 -4340 0 0 {name=p25 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -4040 0 0 {name=p26 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -4140 0 0 {name=p27 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -4600 0 0 {name=x10}
C {lab_wire.sym} 850 -4750 0 0 {name=p28 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -4450 0 0 {name=p29 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -4550 0 0 {name=p30 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -5020 0 0 {name=x11}
C {lab_wire.sym} 850 -5170 0 0 {name=p31 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -4870 0 0 {name=p32 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -4970 0 0 {name=p33 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -5430 0 0 {name=x12}
C {lab_wire.sym} 850 -5580 0 0 {name=p34 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -5280 0 0 {name=p35 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -5380 0 0 {name=p36 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -5840 0 0 {name=x13}
C {lab_wire.sym} 850 -5990 0 0 {name=p37 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -5690 0 0 {name=p38 sig_type=std_logic lab=GND}
C {lab_wire.sym} 730 -5790 0 0 {name=p39 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -6250 0 0 {name=x14}
C {lab_wire.sym} 850 -6400 0 0 {name=p40 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -6100 0 0 {name=p41 sig_type=std_logic lab=GND
}
C {lab_wire.sym} 730 -6200 0 0 {name=p42 sig_type=std_logic lab=vbias}
C {Opamp.sym} 830 -6670 0 0 {name=x15}
C {lab_wire.sym} 850 -6820 0 0 {name=p43 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -6520 0 0 {name=p44 sig_type=std_logic lab=GND
}
C {lab_wire.sym} 730 -6620 0 0 {name=p45 sig_type=std_logic lab=vbias}
C {sg13g2_pr/rppd.sym} 500 -6840 0 0 {name=R2
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -6430 0 0 {name=R3
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -6020 0 0 {name=R4
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -5610 0 0 {name=R5
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -5200 0 0 {name=R6
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -4780 0 0 {name=R7
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -4370 0 0 {name=R8
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -3960 0 0 {name=R9
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -3550 0 0 {name=R10
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -3130 0 0 {name=R11
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -2720 0 0 {name=R12
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -2310 0 0 {name=R13
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -1900 0 0 {name=R14
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -1480 0 0 {name=R15
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 500 -1070 0 0 {name=R16
w=0.5e-6
l=2e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {vsource.sym} 50 -6950 0 0 {name=V1 value=1.4 savecurrent=false}
C {gnd.sym} 50 -6860 0 0 {name=l1 lab=GND}
C {lab_wire.sym} 50 -7010 0 0 {name=p50 sig_type=std_logic lab=VDD}
C {vsource.sym} 130 -6950 0 0 {name=V2 value=0.6 savecurrent=false}
C {gnd.sym} 130 -6860 0 0 {name=l2 lab=GND}
C {lab_wire.sym} 130 -7010 0 0 {name=p51 sig_type=std_logic lab=vbias}
C {gnd.sym} 50 -6600 0 0 {name=l3 lab=GND}
C {vsource.sym} 130 -6690 0 0 {name=Vpulse value="pulse(0 1.2 0 1u 1u 1u 1u)"
}
C {gnd.sym} 130 -6600 0 0 {name=l4 lab=GND}
C {lab_wire.sym} 130 -6750 0 0 {name=p53 sig_type=std_logic lab=vin}
C {simulator_commands_shown.sym} 20 -6460 0 0 {
name=Libs_Ngspice
simulator=ngspice
only_toplevel=false
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
"
      }
C {lab_wire.sym} 590 -1280 0 0 {name=p52 sig_type=std_logic lab=ref2}
C {lab_wire.sym} 580 -1700 0 0 {name=p54 sig_type=std_logic lab=ref3
}
C {lab_wire.sym} 560 -2110 0 0 {name=p55 sig_type=std_logic lab=ref4
}
C {lab_wire.sym} 560 -2520 0 0 {name=p56 sig_type=std_logic lab=ref5}
C {lab_wire.sym} 560 -2930 0 0 {name=p57 sig_type=std_logic lab=ref6}
C {lab_wire.sym} 560 -3350 0 0 {name=p58 sig_type=std_logic lab=ref7}
C {lab_wire.sym} 560 -3760 0 0 {name=p59 sig_type=std_logic lab=ref8}
C {lab_wire.sym} 570 -4170 0 0 {name=p60 sig_type=std_logic lab=ref9}
C {lab_wire.sym} 580 -4580 0 0 {name=p61 sig_type=std_logic lab=ref10}
C {lab_wire.sym} 570 -5000 0 0 {name=p62 sig_type=std_logic lab=ref11}
C {lab_wire.sym} 570 -6650 0 0 {name=p63 sig_type=std_logic lab=ref15}
C {lab_wire.sym} 560 -6230 0 0 {name=p64 sig_type=std_logic lab=ref14}
C {lab_wire.sym} 560 -5820 0 0 {name=p65 sig_type=std_logic lab=ref13}
C {lab_wire.sym} 560 -5410 0 0 {name=p66 sig_type=std_logic lab=ref12}
C {code.sym} 240 -6970 0 0 {name=s1 only_toplevel=false value=".tran 1n 1u
.control
run
write /home/designer/shared/flashadc.raw
.endc"}
C {lab_wire.sym} 680 -6690 0 0 {name=p46 sig_type=std_logic lab=vin}
C {NOR.sym} 1160 -910 0 0 {name=x17}
C {NOR.sym} 1320 -930 0 0 {name=x16}
C {inv.sym} 1070 -800 0 0 {name=x18}
C {NOR.sym} 1480 -950 0 0 {name=x19}
C {NOR.sym} 1640 -970 0 0 {name=x20}
